# IAR project example_mix01.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S105C6 STM8S105C6
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x200
  General.GenHeapSize: 0x1000
  ICCSTM8.CCIncludePath2: Z:\axillent@nas\DIY\AxProjects\lib.c; L:\DIY\AxProjects\lib.c
  ICCSTM8.IccLang: 1
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  ICCSTM8.IccLang: 0
  group (top)
    ./: main.cpp
